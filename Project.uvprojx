# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\Hardware;.\User;.\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F10x\Include;.\Firmware\GD32F10x_standard_peripheral\Include;.\Hardware\rs485;.\Hardware\dip;.\Hardware\buzzer;.\Hardware\led;.\Hardware\key;.\Hardware\seg;.\Hardware\delay;.\Common;.\Hardware\sensor;.\Hardware\icc;.\Hardware\usart;.\App\include;.\Hardware\tm1637;.\Hardware\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Firmware\CMSIS
    ./Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ./Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Firmware\Peripheral
    ./Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Hardware\dip
    ./Hardware/dip/: dip_switch.c
  group Hardware\rs485
    ./Hardware/rs485/: rs485.c
  group Hardware\buzzer
    ./Hardware/buzzer/: buzzer.c
  group Hardware\led
    ./Hardware/led/: led.c
  group Hardware\key
    ./Hardware/key/: key.c
  group Hardware\seg
    ./Hardware/seg/: seg.c
  group Hardware\delay
    ./Hardware/delay/: delay.c
  group Hardware\sensor
    ./Hardware/sensor/: sensor.c
  group Hardware\icc
    ./Hardware/icc/: icc.c
  group Hardware\usart
    ./Hardware/usart/: usart.c
  group App
    ./App/Source/: alarm.c key_process.c rs485_master_task.c rs485_protocol.c rs485_slave_task.c rs485_task.c setting.c system_config.c oled_task.c sensor_uplink.c
  group User
    ./User/: gd32f10x_it.c main.c systick.c
  group Hardware\tm1637
    ./Hardware/tm1637/: tm1637.c
  group Hardware\olde
    ./Hardware/oled/: OLED.c OLED_Data.c
software components: CMSIS:CORE 6.1.1
